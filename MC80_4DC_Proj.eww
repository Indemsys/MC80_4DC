<?xml version="1.0" encoding="UTF-8" standalone="yes"?>
<workspace>
    <project>
        <path>$WS_DIR$\MC80_4DC_Proj.ewp</path>
    </project>
    <batchBuild/>
</workspace>
